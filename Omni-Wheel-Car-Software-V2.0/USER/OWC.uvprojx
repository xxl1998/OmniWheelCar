# Keil uVision project OWC.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OmniWheelCar +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FRAMEWORK;..\HARDWARE_DRIVER\inc;..\MYTASKS;..\FRAMEWORK\FATFS\exfuns;..\FRAMEWORK\FATFS\src;..\FRAMEWORK\MALLOC;..\FRAMEWORK\USB\CONFIG;..\FRAMEWORK\USB\LIB;..\FRAMEWORK
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c includes.h my_config.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_adc.c
  group Hardware_Driver
    ../HARDWARE_DRIVER/src/: delay.c spi1.c sys.c tim2.c usart1.c usart3.c oled.c adc.c tim8_pwm.c tim1_npwm.c exti.c tim4_capture.c usart2.c
  group Tasks
    ../MYTASKS/: BLELinkTask.c BTLinkTask.c EncoderTask.c LedTask.c MotorControlTask.c OLEDTask.c OpenMVLinkTask.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Framework
    ../FRAMEWORK/: motors.c car_4omni_wheel.c CommApp.c pid.c
software components: CMSIS:CORE 5.0.1
